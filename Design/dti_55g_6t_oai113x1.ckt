*##########################################################################################
* Copyright (c) 2023 Dolphin Technology, Inc.
* This netlist is proprietary and confidential information of
* Dolphin Technology, Inc. and can only be used or viewed
* under license or with written permission from Dolphin Technology, Inc.
*##########################################################################################
* /data/projects/stdcells/scripts_svn_update_flow/Update_property_flow/lvsNetlist.pl -c dti_55g_6t_oai113x1 -p /data/projects/stdcells/scripts_svn_update_flow/Update_property_flow/params/params55.sp -s netlist -d lvs -nglob
* dt35-linux:/data/projects/stdcells/REPOSITORY_RV003/ckt/tsmc55
* dti_55g_6t_oai113x1.ckt generated on 5/29/2023 at 13:56:46
*##########################################################################################
* Dependencies
*##########################################################################################

.param wnd=1u wpd=1u

.option scale=1

.global vdd vss vddps vddcs
* DAMN, don't know where the cell is
.subckt dti_55g_6t_oai113x1 VDD VSS C2 B A Z C1 C3
mp4 N1N159 C2 N1N158 VDD pch l=0.06u w=0.23u
mn4 N1N136 C2 VSS VSS nch l=0.06u w=0.23u
mp3 Z C1 N1N159 VDD pch l=0.06u w=0.23u
mp1 Z A VDD VDD pch l=0.06u w=0.23u
mn2 N1N135 B N1N136 VSS nch l=0.06u w=0.23u
mn1 Z A N1N135 VSS nch l=0.06u w=0.23u
mp2 Z B VDD VDD pch l=0.06u w=0.23u
mn3 N1N136 C1 VSS VSS nch l=0.06u w=0.23u
mn5 N1N136 C3 VSS VSS nch l=0.06u w=0.23u
mp5 N1N158 C3 VDD VDD pch l=0.06u w=0.23u
.ends
