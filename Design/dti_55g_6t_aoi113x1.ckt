*##########################################################################################
* Copyright (c) 2023 Dolphin Technology, Inc.
* This netlist is proprietary and confidential information of
* Dolphin Technology, Inc. and can only be used or viewed
* under license or with written permission from Dolphin Technology, Inc.
*##########################################################################################
* /data/projects/stdcells/scripts_svn_update_flow/Update_property_flow/lvsNetlist.pl -c dti_55g_6t_aoi113x1 -p /data/projects/stdcells/scripts_svn_update_flow/Update_property_flow/params/params55.sp -s netlist -d lvs -nglob
* dt35-linux:/data/projects/stdcells/REPOSITORY_RV003/ckt/tsmc55
* dti_55g_6t_aoi113x1.ckt generated on 5/29/2023 at 10:14:34
*##########################################################################################
* Dependencies
*##########################################################################################

.param wnd=1u wpd=1u

.option scale=1

.global vdd vss vddps vddcs
* DAMN, don't know where the cell is
.subckt dti_55g_6t_aoi113x1 VDD VSS C3 A B Z C2 C1
mn5 N1N127 C3 VSS VSS nch l=0.06u w=0.23u
mp5 N1N40 C3 VDD VDD pch l=0.06u w=0.23u
mp1 Z A N1N81 VDD pch l=0.06u w=0.23u
mn1 Z A VSS VSS nch l=0.06u w=0.23u
mn2 Z B VSS VSS nch l=0.06u w=0.23u
mp3 N1N40 C1 VDD VDD pch l=0.06u w=0.23u
mp2 N1N81 B N1N40 VDD pch l=0.06u w=0.23u
mn3 Z C1 N1N106 VSS nch l=0.06u w=0.23u
mp4 N1N40 C2 VDD VDD pch l=0.06u w=0.23u
mn4 N1N106 C2 N1N127 VSS nch l=0.06u w=0.23u
.ends
