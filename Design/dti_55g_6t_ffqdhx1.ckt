*##########################################################################################
* Copyright (c) 2023 Dolphin Technology, Inc.
* This netlist is proprietary and confidential information of
* Dolphin Technology, Inc. and can only be used or viewed
* under license or with written permission from Dolphin Technology, Inc.
*##########################################################################################
* /data/projects/stdcells/scripts_svn_update_flow/Update_property_flow/lvsNetlist.pl -c dti_55g_6t_ffqdhx1 -p /data/projects/stdcells/scripts_svn_update_flow/Update_property_flow/params/params55.sp -s netlist -d lvs -nglob
* dt35-linux:/data/projects/stdcells/REPOSITORY_RV003/ckt/tsmc55
* dti_55g_6t_ffqdhx1.ckt generated on 5/29/2023 at 11:18:5
*##########################################################################################
* Dependencies
*##########################################################################################

.param wnd=1u wpd=1u

.option scale=1

.global vdd vss vddps vddcs
* DAMN, don't know where the cell is
.subckt dti_55g_6t_ffqdhx1 VDD VSS D CK Q
mpmos_fbmlb N1N78 MLB VDD VDD pch l=0.06u w=0.15u
mnmos_fbck ML CK N1N79 VSS nch l=0.06u w=0.15u
mnmos_fbmlb N1N79 MLB VSS VSS nch l=0.06u w=0.15u
mpmos_fbckb ML CKB N1N78 VDD pch l=0.06u w=0.15u
mpmos_fbck SLB CK N1N92 VDD pch l=0.06u w=0.15u
mnmos_fbckb SLB CKB N1N94 VSS nch l=0.06u w=0.15u
mnmos_fbsl N1N94 FBSL VSS VSS nch l=0.06u w=0.15u
mpmos_fbsl N1N92 FBSL VDD VDD pch l=0.06u w=0.15u
xinv_slb VDD VSS SLB FBSL dti_gen_inv wn=0.15u wp=0.15u
mnmos_d DLB D VSS VSS nch l=0.06u w=0.23u
mnmos_fbckb_1 N1N206 CKB VSS VSS nch l=0.06u w=0.23u
mnmos_dlb ML DLB N1N206 VSS nch l=0.06u w=0.23u
mpmos_dlb ML DLB N1N203 VDD pch l=0.06u w=0.23u
mpmos_fbck_1 N1N203 CK VDD VDD pch l=0.06u w=0.23u
mpmos_d DLB D VDD VDD pch l=0.06u w=0.23u
xinv_ck VDD VSS CK CKB dti_gen_inv wn=0.23u wp=0.23u
xinv_q VDD VSS SLB Q dti_gen_inv wn=0.23u wp=0.23u
xinv_ml VDD VSS ML MLB dti_gen_inv wn=0.23u wp=0.23u
xtx_slb VDD VSS CKB CK MLB SLB dti_gen_tx wn=0.23u wp=0.23u
.ends

* DAMN, don't know where the cell is
.subckt dti_gen_inv VDD VSS A Z ln=0.06u lp=0.06u wn=0.15u wp=0.15u
m1i3 Z A VDD VDD pch l=lp w=wp
m1i4 Z A VSS VSS nch l=ln w=wn
.ends

* DAMN, don't know where the cell is
.subckt dti_gen_tx VDD VSS PG NG IN OUT wn=0.15u wp=0.15u
m1i3 IN PG OUT VDD pch l=0.06u w=wp
m1i2 IN NG OUT VSS nch l=0.06u w=wn
.ends
